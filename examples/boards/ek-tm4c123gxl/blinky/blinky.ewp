# IAR project blinky.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..\..
  OBJCOPY.OOCOutputFile: blinky.bin
  ILINK.IlinkOutputFile: blinky.out
  ILINK.IlinkIcfFile: blinky.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../../driverlib/: cpu.c interrupt.h Nokia5110.c pwm.c timer.c
    ../../../../../TivaWare(blink)/inc/: hw_ints.h
    ../../../../utils/: uartstdio.c uartstdio.h
  group Source
    ../../../../driverlib/: adc.c gpio.c sysctl.c
    ./: blinky.c startup.c
    ../drivers/: rgb.h
    ../../../../../TivaWare(blink)/driverlib/: rom.h
