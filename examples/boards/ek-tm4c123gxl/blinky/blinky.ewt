<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Source</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\driverlib\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\blinky.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\driverlib\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\drivers\rgb.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\TivaWare(blink)\driverlib\rom.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\startup.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\driverlib\sysctl.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\..\..\driverlib\cpu.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\..\..\TivaWare(blink)\inc\hw_ints.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\..\driverlib\interrupt.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\..\driverlib\Nokia5110.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\..\driverlib\pwm.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\..\driverlib\timer.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\..\utils\uartstdio.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\..\..\utils\uartstdio.h</name>
  </file>
</project>


